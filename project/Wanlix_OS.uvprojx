# Keil uVision project Wanlix_OS.uvprojx, settings and files
target Wanlix_OS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Wanlix_OS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\lib\inc;..\others;..\srccode;..\wanlix;..\srccode\DEVICE\LED;..\srccode\DEVICE\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group wanlix
    ../wanlix/: wanlix.h wlx_core_a.asm wlx_core_c.c
  group srccode
    ../srccode/: global.h main.c stm32f10x_it.c system_stm32f10x.c
    ../srccode/DEVICE/LED/: device.c
    ../srccode/DEVICE/OLED/: draw_api.c oled.c
  group others
    ../others/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
